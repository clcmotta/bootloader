# Keil uVision project demo.uvprojx, settings and files
target demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo +hex
  AfterMake: E:\keil\ARM\ARMCC\bin\fromelf.exe   --bin -o  .\OBJ\demo.bin .\OBJ\demo.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X,USE_STDPERIPH_DRIVER
  c include: .\LIB\CMSIS;.\LIB\FWlib\inc;.\USER;.\USER\HARDWARE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ./LIB/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ./LIB/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ./LIB/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ./USER/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group HARDWARE
    ./USER/HARDWARE/: usart.c delay.c sys.c led.c
